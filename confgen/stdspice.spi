*
* Include .lib for all the devices
*
.lib '/path/to/spice/lib/' TT
